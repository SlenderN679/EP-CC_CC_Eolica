#include <Stdlib.h>
#include <String.h>
#include <math.h>
#include <Psim.h>

/////////////////////////////////////////////////////////////////////
// Dual-mode controller for a 2-phase interleaved boost
//   MODE_V    : fast PI voltage loop (1 ms) regulates Vout = 100 V
//   MODE_MPPT : slow variable-step P&O (50 ms) when the source
//               cannot supply the power the load needs at 100 V
//
// Inputs : in[0] = Vin  (boost input voltage, filtered)
//          in[1] = Iin  (rectifier output current, filtered)
//          in[2] = Vout (output voltage across C3, filtered)
// Outputs: out[0] = duty cycle D (0..1) -> STM_TIM block
//          out[1] = mode (1 = voltage regulation, 0 = MPPT)  -- optional
/////////////////////////////////////////////////////////////////////

#define MODE_MPPT 0
#define MODE_V    1

// ---------------- General ----------------
static const double D_MAX      = 0.85;
static const double D_MIN      = 0.05;
static const double D_INIT     = 0.20;
static const double T_START    = 0.05;   // let C3 pre-charge before control [s]
static const double V_OUT_REF  = 100.0;  // output voltage reference [V]
static const double V_ENTER    = 3.0;    // hand over to PI when Vout > ref - 3 V

// ---------------- Fast voltage loop ----------------
static const double T_V        = 0.001;  // PI execution period [s]
static const double KP_V       = 0.001;  // duty per volt
static const double KI_V       = 0.3;    // duty per volt-second (~10 Hz crossover)
static const double V_DROP     = 5.0;    // undervoltage that suggests power limit [V]
static const double T_DROP     = 0.05;   // ...sustained this long -> switch to MPPT [s]

// ---------------- Slow MPPT loop ----------------
static const double T_MPPT     = 0.05;   // = 15 x 300 Hz ripple periods
static const double STEP_MIN   = 0.002;
static const double STEP_MAX   = 0.02;
static const double K_STEP     = 2.5e-5; // step = K_STEP * |dP/dD|
static const double DP_TOL     = 0.003;  // reverse only if P drops > 0.3 %
static const double V_SLOW     = 3.0;    // within 3 V of ref, use STEP_MIN

// Sensor scaling: set to 1/gain of the sensors if not unity
static const double KV_IN  = 1.0;
static const double KI_IN  = 1.0;
static const double KV_OUT = 1.0;

// ---------------- State ----------------
static int    mode, nIn, nOut, mppt_first;
static double D, D_int, D_prev, dir, P_prev;
static double t_last, t_fast, t_low;
static double sumP, sumVo, sumT;    // MPPT window
static double sumVf, sumTf;         // fast window

static void enter_mppt(double t)
{
    mode       = MODE_MPPT;
    mppt_first = 1;          // first window only measures
    dir        = 1.0;
    D_prev     = D;
    sumP = sumVo = sumT = 0.0;
    t_last     = t;
}

static void enter_vreg(void)
{
    mode  = MODE_V;
    D_int = D;               // bumpless transfer
    t_low = 0.0;
}

static double clampD(double x)
{
    if (x > D_MAX) return D_MAX;
    if (x < D_MIN) return D_MIN;
    return x;
}

/////////////////////////////////////////////////////////////////////
void SimulationStep(
		double t, double delt, double *in, double *out,
		 int *pnError, char * szErrorMsg,
		 void ** reserved_UserData, int reserved_ThreadIndex, void * reserved_AppPtr)
{
    double Vin  = in[0] * KV_IN;
    double Iin  = in[1] * KI_IN;
    double Vout = (nIn >= 3) ? in[2] * KV_OUT : Vin / (1.0 - D);

    if (t < T_START) {
        t_last = t_fast = t;
        out[0] = D;
        if (nOut >= 2) out[1] = (double)mode;
        return;
    }

    sumP  += Vin * Iin * delt;
    sumVo += Vout * delt;
    sumT  += delt;
    sumVf += Vout * delt;
    sumTf += delt;

    // ================= FAST LOOP (1 ms) =================
    if ((t - t_fast) >= T_V && sumTf > 0.0) {
        double Vo_f = sumVf / sumTf;
        sumVf = sumTf = 0.0;
        t_fast = t;

        if (mode == MODE_V) {
            double e = V_OUT_REF - Vo_f;

            D_int = clampD(D_int + KI_V * e * T_V);   // anti-windup by clamping
            D     = clampD(D_int + KP_V * e);

            // Sustained undervoltage -> source can't deliver -> MPPT
            if (e > V_DROP) t_low += T_V; else t_low = 0.0;
            if (t_low >= T_DROP) enter_mppt(t);
        }
        else if (Vo_f >= V_OUT_REF - V_ENTER) {
            // Close to 100 V -> let the PI finish the approach and regulate
            // (hysteresis: enter at ref-3 V, leave at ref-5 V for 50 ms)
            enter_vreg();
        }
    }

    // ================= SLOW LOOP (50 ms, MPPT only) =================
    if (mode == MODE_MPPT && (t - t_last) >= T_MPPT && sumT > 0.0) {
        double P_avg  = sumP  / sumT;
        double Vo_avg = sumVo / sumT;
        double D_applied = D;
        sumP = sumVo = sumT = 0.0;
        t_last = t;

        if (mppt_first) {
            mppt_first = 0;
            D += dir * STEP_MIN;
        }
        else {
            double dP = P_avg - P_prev;
            double dD = D_applied - D_prev;

            if (dP < -DP_TOL * P_prev) dir = -dir;

            double step = STEP_MIN;
            if (fabs(dD) > 1e-6) step = K_STEP * fabs(dP / dD);
            if (step > STEP_MAX) step = STEP_MAX;
            if (step < STEP_MIN) step = STEP_MIN;
            if (Vo_avg > V_OUT_REF - V_SLOW) step = STEP_MIN;

            D += dir * step;
        }

        D      = clampD(D);
        D_prev = D_applied;
        P_prev = P_avg;
    }

    out[0] = D;
    if (nOut >= 2) out[1] = (double)mode;
}

/////////////////////////////////////////////////////////////////////
void SimulationBegin(
		const char *szId, int nInputCount, int nOutputCount,
		 int nParameterCount, const char ** pszParameters,
		 int *pnError, char * szErrorMsg,
		 void ** reserved_UserData, int reserved_ThreadIndex, void * reserved_AppPtr)
{
    nIn   = nInputCount;
    nOut  = nOutputCount;
    D     = D_INIT;
    D_int = D_INIT;
    P_prev = 0.0;
    t_low  = 0.0;
    t_fast = 0.0;
    sumVf = sumTf = 0.0;
    enter_mppt(0.0);   // start-up: track power until Vout reaches 100 V
}

/////////////////////////////////////////////////////////////////////
void SimulationEnd(const char *szId, void ** reserved_UserData, int reserved_ThreadIndex, void * reserved_AppPtr)
{
}